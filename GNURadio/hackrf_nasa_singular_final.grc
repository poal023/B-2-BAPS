options:
  parameters:
    generate_options: qt_gui
    id: hackrf_nasa_singular_final
    output_language: python
  states: {}

blocks:
- name: cutoff_f0
  id: variable_qtgui_range
  parameters:
    label: cutoff
    start: samp_rate/8
    step: 10e3
    stop: samp_rate/2
    value: samp_rate/4
  states: {}
- name: freq0
  id: variable
  parameters:
    value: 2e9
  states: {}
- name: gain0
  id: variable_qtgui_range
  parameters:
    label: gain0
    start: '0'
    step: '1'
    stop: '47'
    value: '15'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: transition_width
  id: variable_qtgui_range
  parameters:
    label: transition_width
    start: samp_rate/16
    step: 10e3
    stop: samp_rate/4
    value: samp_rate/8
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters:
    vlen: '1024'
  states: {}
- name: blocks_stream_to_vector_0
  id: blocks_stream_to_vector
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate / 8
    type: complex
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1024'
    type: float
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: '1024'
    type: complex
  states: {}
- name: digital_mpsk_snr_est_cc_0
  id: digital_mpsk_snr_est_cc
  parameters:
    alpha: '0.001'
    tag_nsamples: '10000'
    type: '1'
  states: {}
- name: fft_vxx_0
  id: fft_vxx
  parameters:
    fft_size: '1024'
    forward: 'True'
    shift: 'True'
    type: complex
    window: window.blackmanharris(1024)
  states: {}
- name: osmosdr_source_1
  id: osmosdr_source
  parameters:
    ant0: RX
    args: hackrf=0000000000000000f77c60dc2a139dc3
    bb_gain0: '24'
    bw0: 10e6
    dc_offset_mode0: '2'
    freq0: freq0
    gain0: gain0
    gain_mode0: 'True'
    if_gain0: '24'
    iq_balance_mode0: '2'
    sample_rate: 'samp_rate '
    sync: pc_clock
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq0
    fftsize: '1024'
    label1: 9dc3 Output
    showports: 'True'
    type: float
  states: {}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    label1: Time Domain
    size: '1024'
    srate: samp_rate
    type: float
    update_time: '0.00010'
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5566
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', blocks_vector_to_stream_0, '0']
- [blocks_stream_to_vector_0, '0', fft_vxx_0, '0']
- [blocks_throttle_0, '0', digital_mpsk_snr_est_cc_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_freq_sink_x_0, '0']
- [blocks_vector_to_stream_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_vector_to_stream_0_0, '0', blocks_throttle_0, '0']
- [digital_mpsk_snr_est_cc_0, '0', zeromq_pub_sink_0, '0']
- [fft_vxx_0, '0', blocks_complex_to_mag_0, '0']
- [fft_vxx_0, '0', blocks_vector_to_stream_0_0, '0']
- [osmosdr_source_1, '0', blocks_stream_to_vector_0, '0']

metadata:
  file_format: 1
